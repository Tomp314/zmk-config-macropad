## boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

# Name must be less than 16 characters long!
config ZMK_MACROPAD
    default "macropad"

endif
```
